FILESEXTRAPATHS:append := ":${THISDIR}/files"

HOSTAPP_HOOKS += " \
    99-resin-uboot \
"
