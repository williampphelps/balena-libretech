inherit kernel-balena deploy
